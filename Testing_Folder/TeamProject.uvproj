# Keil uVision project TeamProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: TeamProject
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../../github/brainstorm/mc_testing_code/: main-1.c
